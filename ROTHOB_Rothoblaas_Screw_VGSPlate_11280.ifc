Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: db5082bd-1385-4c62-a070-9f1dd305d88c, NumberOfSaves: 12], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Screw_VGSPlate_11280.ifc
Time: 2026-05-11T09:20:32
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMechanicalFastener: Structural Connections : ROTHOB_Rothoblaas_Screw_VGSPlate : VGSPL11280_11x280mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized_Black
Type - Data - AtmosphericCorrosivity: C1 | C2; ServiceClass: SC1 | SC2; WoodCorrosivity: T1 | T2
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_VGSPlate; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.24; OmniClassTitle: Screws; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/screws/vgs-plate; Revision: 001; UniClass2015Code: Pr_20_29_76_75; UniClass2015Title: Self-tapping screws; UniClass2015Version: Products v1.41; Version: 001
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 11280
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized_Black
Type - Dimensions - HeadDiameter_dk: 20 mm; HeadDiameterS_dks: 16.5 mm; HeadThickness_t1: 16.25 mm; HeadWasherThickness_twt: 2.5 mm; HexagonalHeadThickness_ts: 5.75 mm; HoleDiameterOnSteelPlate_dvs: 13 mm; InsertionLength_L: 280 mm; NominalDiameter_d1: 11 mm; PredrillingHoleDiameterHardwood_dvh: 7 mm; PredrillingHoleDiameterSoftwood_dvs: 6 mm; ThreadDiameter_d2: 6.6 mm; ThreadLength_b: 270 mm; TipLength_Lt: 13.2 mm; UnderheadDiameter_duk: 12 mm; UnderheadLength_L1: 3 mm; WrenchSize_SW: 17 mm
Type - Identity Data - Description: Pan Head Hexagonal Screw for lifting; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.20.40.11.14.24; OmniClass Title: Screws; Type Name: VGSPL11280_11x280mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-11/0030; CETitle: Rotho Blaas Self-tapping screws and threaded rods; CodePerformance: CE - Construction products; Color: Black; Constituents: n/a; Description_2: Pan Head Hexagonal Screw for lifting; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Screw_VGSPlate; Features: Full-threaded screw for lifting or steel-timber connection; Finish: Black zinc plated; Grade: n/a; GTIN: 8055598651761; ICC-ESCode: ESR-4645 | ELC-4645; ICC-ESTitle: Rotho blaas self-tapping wood screws | Rotho Blaas Self-tapping Wood Screws; Manufacturer_2: info@rothoblaas.com; Material: Electrogalvanized carbon steel; MinWeight: 0.118 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VGSPL11280; ModelReference: n/a; Name: Screw; NominalDiameter: 11 mm; NominalHeight: n/a; NominalLength: 280 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 11x280 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Black
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Screw
Pset_QuantityTakeOff - Reference: VGSPL11280_11x280mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: RB_0
Dimensions - Area: 0.00360483 m2; Volume: 0.0000115489 m3
Other - Family: ROTHOB_Rothoblaas_Screw_VGSPlate; Family and Type: ROTHOB_Rothoblaas_Screw_VGSPlate: VGSPL11280_11x280mm; InstallationDate: n/a; Type: VGSPL11280_11x280mm; Type Id: 772366; WarrantyStartDate: n/a
